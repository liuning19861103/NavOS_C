# Keil uVision project MagDataAnalysis.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IIKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MagDataAnalysis (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,UART_SIGLE_BYTE_MODE,ARM_MATH_CM7,__CC_ARM,STM_RUN,SYS_MATH_LIB,DEV_FIR_MODE,GNSS_HXXT_TEST_188
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\Sources\Algorithm;..\..\Sources\Driver;..\..\Sources\Interaction;..\..\Sources\System;..\..\Sources\Users;..\..\Drivers\CMSIS\Device;..\..\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../../Sources/Algorithm/: MagDataAnalysis.c
