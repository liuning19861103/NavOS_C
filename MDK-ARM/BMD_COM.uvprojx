# Keil uVision project BMD_COM.uvprojx, settings and files
target BMD_COM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IIKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: BMD_COM +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\BMD_COM\BMD_COM.bin .\BMD_COM\BMD_COM.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,UART_SIGLE_BYTE_MODE,ARM_MATH_CM7,__CC_ARM,STM_RUN,SYS_MATH_LIB,DEV_FIR_MODE,GNSS_HXXT_TEST_188
  c include: ../Inc;           ../Drivers/STM32F7xx_HAL_Driver/Inc;           ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;           ../Drivers/CMSIS/Include;           ..\Sources\Algorithm;           ..\Sources\Driver;           ..\Sources\Interaction;           ..\Sources\System;           ..\Sources\Users
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Task/Users
    ../Sources/Users/: Config.c ConfigInit.c InterruptInit.c TaskSequenceInit.c
    ../GenLib/Interrupt/Objects/: Interrupt.lib
    ../GenLib/TaskSequence/Objects/: TaskSequence.lib
    ../GenLib/TransmitData/Objects/: TransmitData.lib
  group Task/Interactions
    ../Sources/Interaction/: DataLinkInit.c DataStorageInit.c ExtDevConInit.c PulseEngineInit.c
    ../GenLib/DataLink/Objects/: DataLink.lib
    ../GenLib/DataStorage/Objects/: DataStorage.lib
    ../GenLib/ExtDevCon/Objects/: ExtDevCon.lib
    ../GenLib/PulseEngine/Objects/: PulseEngine.lib
  group Task/Algorithm
    ../Sources/Algorithm/: DataAnalysis.c DataAnalysisInit.c DevCompensationInit.c INSSolveInit.c KFFilterInit.c MagDataAnalysisInit.c MatrixInit.c PDRSolveInit.c BasControl.c BasControlInit.c
    ../GenLib/DevCompensation/Objects/: DevCompensation.lib
    ../GenLib/INSSolve/Objects/: INSSlove.lib
    ../GenLib/KFFilter/Objects/: KFFilter.lib
    ../GenLib/MagDataAnalysis/Objects/: MagDataAnalysis.lib
    ../GenLib/Matrix/Objects/: Matrix.lib
    ../GenLib/PDRSolve/Objects/: PDRSolve.lib
  group Task/Driver
    ../Sources/Driver/: Delay.c GNSSSolveInit.c SensorDataFilter.c SensorRead.c SensorReadInit.c
    ../GenLib/GNSSSolve/Objects/: GNSSSolve.lib
  group Task/System
    ../Sources/System/: GlobalDefineInit.c GlobalDefine.h IMUConfig.h PlatformCon.h SysKeyWord.h Encryption.c
    ../Sources/Users/: Readme.md
  group Application/User
    ../Src/: main.c gpio.c dma.c fmc.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
